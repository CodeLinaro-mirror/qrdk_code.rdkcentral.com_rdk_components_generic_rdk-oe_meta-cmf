SRC_URI:remove = "git://github.com/open-source-parsers/jsoncpp.git"
SRC_URI += "git://github.com/open-source-parsers/jsoncpp.git;protocol=https;branch=master"
