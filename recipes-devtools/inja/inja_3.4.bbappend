SRC_URI_remove = "git://github.com/pantor/inja.git;tag=v3.4.0"
SRC_URI += "git://github.com/pantor/inja.git;branch=main;protocol=https;tag=v3.4.0"
