EXTRA_OECONF:remove_broadband = "no-md4"
EXTRA_OECONF:remove_extender = "no-md4"

EXTRA_OECONF:remove_camera = "no-rc4"
