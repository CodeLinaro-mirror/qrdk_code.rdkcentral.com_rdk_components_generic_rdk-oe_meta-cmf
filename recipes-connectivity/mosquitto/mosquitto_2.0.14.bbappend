PACKAGECONFIG:remove = " websockets"
