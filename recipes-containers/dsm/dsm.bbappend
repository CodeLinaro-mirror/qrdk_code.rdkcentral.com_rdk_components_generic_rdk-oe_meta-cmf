SRCREV_kirkstone = "2e3acfea258c2a9f5eae179354c989736f7d8610"
DEPENDS_append_kirkstone = " dobby "
