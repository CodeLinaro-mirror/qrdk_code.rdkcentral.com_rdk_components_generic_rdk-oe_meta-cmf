FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://248.patch"
