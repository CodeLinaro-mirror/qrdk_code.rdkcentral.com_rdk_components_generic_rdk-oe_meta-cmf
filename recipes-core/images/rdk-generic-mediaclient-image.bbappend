require add-non-root-user-group.inc
require lxc-image.inc

## generate libs json file for BundleGenerator
inherit generate_libs_json
