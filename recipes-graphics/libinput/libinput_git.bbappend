SRC_URI:remove = "git://anongit.freedesktop.org/git/wayland/libinput;branch=master"
SRC_URI += "git://gitlab.freedesktop.org/libinput/libinput.git;protocol=${CMF_GIT_PROTOCOL};branch=main"
