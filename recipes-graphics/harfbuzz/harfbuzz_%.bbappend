EXTRA_OECONF:remove = "--with-cairo=no"
EXTRA_OECONF += "--with-cairo=no"
