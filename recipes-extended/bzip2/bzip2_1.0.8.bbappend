PACKAGES:remove:wrynose = "bzip2-staticdev bzip2-locale bzip2-ptest"