SRC_URI_remove = "git://github.com/rdkcentral/rdkservices.git;protocol=git;branch=topic/feature-rdkvm"
SRC_URI += "git://github.com/rdkcentral/rdkservices.git;protocol=https;branch=topic/feature-rdkvm"

inherit coverity
