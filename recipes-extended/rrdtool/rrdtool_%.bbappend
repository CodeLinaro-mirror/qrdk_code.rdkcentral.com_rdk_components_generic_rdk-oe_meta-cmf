PACKAGECONFIG:append = " graph"
