DEPENDS:remove = "mountutils"
DEPENDS:remove = "ssacpc"

DEPENDS:append = " rdk-logger"

EXTRA_OECONF:remove = "--enable-cspcrdkconfig"
