SRC_URI:remove = "git://github.com/KDE/heaptrack"
SRC_URI += "git://github.com/KDE/heaptrack;protocol=https;branch=master"
