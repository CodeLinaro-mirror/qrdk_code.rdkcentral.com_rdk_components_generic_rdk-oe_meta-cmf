SRC_URI = "https://www.deepspace6.net/ftp/pub/ds6/sources/ipv6calc/ipv6calc-${PV}.MISUSED.tar.gz"
