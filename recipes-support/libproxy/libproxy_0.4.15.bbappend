# Already in openembedded-core/meta/recipes-support/libproxy/libproxy_0.4.15.bb, rdk/dunfell branch
SRC_URI:remove  = "file://CVE-2020-25219_fix.patch"
SRC_URI:remove  = "file://CVE-2020-26154_fix.patch"
