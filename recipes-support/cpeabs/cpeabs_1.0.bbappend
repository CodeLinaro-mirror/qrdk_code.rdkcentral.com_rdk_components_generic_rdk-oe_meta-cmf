SRC_URI:remove = "git://github.com/xmidt-org/cpeabs.git"
SRC_URI += "git://github.com/xmidt-org/cpeabs.git;protocol=https;branch=master"
