SRC_URI:remove = "file://0001-PPP-When-un-escaping-don-t-allocate-a-too-large-buff.patch"
