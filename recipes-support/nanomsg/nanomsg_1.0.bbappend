SRC_URI:remove = "git://github.com/nanomsg/nanomsg.git"
SRC_URI += "git://github.com/nanomsg/nanomsg.git;protocol=https;branch=master"
